## sdkconfig.defaults
```kconfig
CONFIG_IDF_FIRMWARE_CHIP_ID=0x0009
CONFIG_RMT_ENABLE_DEBUG_LOG=n
CONFIG_RMT_ISR_IRAM_SAFE=y
```
